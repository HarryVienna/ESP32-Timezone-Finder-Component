## sdkconfig.defaults
```kconfig
#
# FreeRTOS
#
CONFIG_FREERTOS_HZ=100

#
# ESP32-specific
#
CONFIG_ESP32_RTC_CLK_SRC_INT_8MD256=y
```
